# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target STM32F103C8T6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: lib\cmsis;.eide\deps;MultMenu\application;MultMenu\disp;MultMenu\menu;src;src\u8g2Drive;src\u8g2Lib\inc;src\led;src\uart;src\button;src\timerTick;src\SEGGER_RTT;src\encoder;src\u8g2Lib\src;src\i2cDrive;hal\STM32F10x_StdPeriph_Driver;hal\STM32F10x_StdPeriph_Driver\src;hal\STM32F10x_StdPeriph_Driver\inc
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SRC
    src/: main.c startup_stm32f10x_md.s stm32f10x_it.c
  group SRC/UART
    src/uart/: bsp_usart.c
  group SRC/U8G2LIB/SRC
    src/u8g2Lib/src/: mui.c mui_u8g2.c U8g2lib.cpp u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c U8x8lib.cpp u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_debounce.c u8x8_display.c u8x8_d_ssd1306_128x64_noname.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
  group SRC/U8G2DRIVE
    src/u8g2Drive/: stm32_u8g2.c
  group SRC/TIMERTICK
    src/timerTick/: TimerTick.c
  group SRC/SEGGER_RTT
    src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SRC/I2CDRIVE
    src/i2cDrive/: I2cDrive.c
  group SRC/ENCODER
    src/encoder/: rotary_encoder.c
  group HAL/STM32F10X_STDPERIPH_DRIVER
    hal/STM32F10x_StdPeriph_Driver/: system_stm32f10x.c
  group HAL/STM32F10X_STDPERIPH_DRIVER/SRC
    hal/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MULTMENU/MENU
    MultMenu/menu/: menu.c
  group MULTMENU/DISP
    MultMenu/disp/: dispDirver.c
  group MULTMENU/APPLICATION
    MultMenu/application/: AirPlane.c application.c DinoGame.c
