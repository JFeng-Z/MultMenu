# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .cmsis\include;RTE\_Target 1;.eide\deps;HARDWARE;HARDWARE\Encoder;HARDWARE\KEY;HARDWARE\LED;HARDWARE\uart;FreeRTOS\include;FreeRTOS\src;FreeRTOS\port\RVDS\ARM_CM3;FreeRTOS\port\MemMang;User;Libraries\CMSIS;Libraries\STM32F10x_StdPeriph_Driver\inc;HARDWARE\MPU6050;HARDWARE\MPU6050\eMPL;HARDWARE\MENU;HARDWARE\APP;.\HARDWARE\I2cDrive;.\HARDWARE\U8G2Drive;.\HARDWARE\U8G2LIB\inc;.\HARDWARE\TimerTick
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FREERTOS/SRC
    FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOS/PORT/RVDS/ARM_CM3
    FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FREERTOS/PORT/MEMMANG
    FreeRTOS/port/MemMang/: heap_4.c
  group HARDWARE/UART
    HARDWARE/uart/: bsp_usart.c
  group HARDWARE/U8G2LIB/SRC
    HARDWARE/u8g2lib/src/: mui.c mui_u8g2.c U8g2lib.cpp u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c U8x8lib.cpp u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_debounce.c u8x8_display.c u8x8_d_ssd1306_128x64_noname.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
  group HARDWARE/MPU6050
    HARDWARE/MPU6050/: mpu6050.c mpuiic.c
  group HARDWARE/MPU6050/EMPL
    HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group HARDWARE/MENU
    HARDWARE/MENU/: Menu.c
  group HARDWARE/LED
    HARDWARE/LED/: bsp_led.c
  group HARDWARE/KEY
    ./HARDWARE/KEY/: Key_Driver.c multi_button.c
  group USER
    User/: FreeRTOSConfig.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group STARTUP
    Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    Doc/: ReadMe.txt
  group CMSIS
    Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group HARDWARE/APP
    ./HARDWARE/APP/: AirPlane.c DinoGame.c Other_Function.c Time.c
  group HARDWARE/I2cDrive
    ./HARDWARE/I2cDrive/: I2cDrive.c
  group HARDWARE/U8G2Drive
    ./HARDWARE/U8G2Drive/: stm32_u8g2.c U8g2_User.c
  group HARDWARE/TimerTick
    ./HARDWARE/TimerTick/: TimerTick.c
